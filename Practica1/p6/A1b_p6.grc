options:
  parameters:
    generate_options: qt_gui
    id: Lab_punto5b
    output_language: python
    title: Lab_comu
  states: {}

blocks:
- name: AMP
  id: variable_qtgui_range
  parameters:
    label: AMP
    start: '1'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: BW
  id: variable_qtgui_range
  parameters:
    label: ancho de banda
    start: '10'
    step: '10'
    stop: '50000'
    value: '1500'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: f_corte
  id: variable_qtgui_range
  parameters:
    label: frecuencia de corte
    start: '100'
    step: '10'
    stop: '21000'
    value: '1500'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia central
    start: '100'
    step: '10'
    stop: '21000'
    value: '1500'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: frecuencia de muestreo
    start: '1000'
    step: '1000'
    stop: '300000'
    value: '200000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: fc+BW/2
    interp: '1'
    low_cutoff_freq: fc-BW/2
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: AMP
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/carlos/Descargas/session52_quevedobzrp.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: f_corte
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_corte
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '200000'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '200000'
    interp: '48000'
    type: fff
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [high_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', band_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', high_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']

metadata:
  file_format: 1
